# IAR project ble_aci_transport_layer_verification.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 256
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: ..\..\RL78\; ..\..\BLE\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkr5f100le.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  General.GenStackSize: 128
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group BLE
    ../../BLE/: aci_queue.cpp aci_setup.cpp acilib.cpp hal_aci_tl.cpp hal_platform.cpp lib_aci.cpp
  group RL78_common
    ../../RL78/: CG_port.c CG_serial.c CG_system.c CG_systeminit.c CG_timer.c
